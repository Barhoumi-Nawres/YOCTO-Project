# The is automatic generated Code by "makePipRecipes.py"
# (build by Robin Sebastian (https://github.com/robseb) (git@robseb.de) Vers.: 1.2) 

SUMMARY = "Recipe to embedded the Python PiP Package cloudinary"
HOMEPAGE ="https://pypi.org/project/cloudinary"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=10a367181a5d1e57268a7272e7934305"

inherit pypi setuptools3
PYPI_PACKAGE = "cloudinary"
SRC_URI[md5sum] = "b2aaf9ad19a1753f20781b9281d16c20"
SRC_URI[sha256sum] = "88571d8ed3366797bdbaec87e452471f7e09c1f767f83390efca326dd1cbcc8f"
