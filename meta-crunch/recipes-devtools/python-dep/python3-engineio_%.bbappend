

PV="3.14.2" 


LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=42d0a9e728978f0eeb759c3be91536b8"

SRC_URI[sha256sum] = "eab4553f2804c1ce97054c8b22cf0d5a9ab23128075248b97e1a5b2f29553085"

